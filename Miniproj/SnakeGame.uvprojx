# Keil uVision project SnakeGame.uvprojx, settings and files
target SnakeGame_Release (6240000::V6.24::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SnakeGame +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\drivers
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Entry
    ./src/: main.c main_tilt.c
  group drivers
    ./drivers/: gpio.c gpio.h i2c.c i2c.h platform.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_usart.c stm32f4xx_usart.h timer.c timer.h uart.c uart.h
  group c_files
    ./src/cfiles/: buttons.c delay.c ds18s20.c foun5x7.c i2c1_bus.c mpu6500.c OLED.c onewire.c timer_delay.c Kalman.c
  group h_files
    ./src/hfiles/: app.h buttons.h delay.h ds18s20.h font5x7.h i2c1_bus.h Kalman.h lcd.h mpu6500.h tilt_input.h OLED.h menu.h onewire.h snake_game.h snake_render.h snake_types.h temp_sensor.h timer_delay.h ui_display.h utils.h
  group External_lib_files
    ./src/Libfiles/: LCDFunctions.lib ProjectSupport.lib
  group Application
    ./src/: app.c menu.c snake_game.c snake_render.c temp_sensor.c mpu6500.c tilt_input.c utils.c ui_display.c
software components: CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.2.0, Device:Startup 2.6.3
